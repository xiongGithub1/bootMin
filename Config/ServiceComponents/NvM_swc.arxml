<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="ef5dcac0-2a06-4e1e-813d-b20efe1cdae7">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="dec90451-c747-4b74-b70e-8bd4ad750bcf">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="840ef39b-29c8-4b23-b5ca-3bf523b31970">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="a97cb41a-ee13-435d-bc30-1f583f61241f">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="70ec41b1-0783-4b84-ae0c-229d306f2a9d">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6ce29beb-bc31-4ff1-9c1a-b9bc0b1c10d1">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
