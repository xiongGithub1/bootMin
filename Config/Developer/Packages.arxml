<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00048.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="311EA7E4-86A0-4686-B97E-AEE414F3855A">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7350F044-311E-4F84-A6A9-582CA974DAAC">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7DB29255-4B53-4A66-B362-99510D7DCAC8">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3E26AFE2-09AF-4C28-B7E9-796C3155A984">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="82724672-8DB0-48D8-9E6D-CFF19AB96823">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DB776467-AB7E-4811-AC2E-AC821E759962">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="8A4383B1-8F1B-41C0-84D6-E88E28FE7142">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7520363D-F3B6-43D6-A240-860D538C5C2F">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EBB020BB-FC9D-4338-B9B4-F00E223B66C0">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C7A346F8-429F-462E-A447-E1B05C1B5D07">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C9DDA1CB-3B7B-4876-A9A9-36223772C0FF">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9ABD2C6A-9FE9-4403-93EA-351693A85BE1">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9AF0C9D2-B3C7-454A-9355-B8A55B841AEA">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3433654A-40AF-4F1C-B6CF-A768EF928CA1">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D18EC2BC-0D70-4251-98FA-135B99DB8DEF">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7716A374-91B6-4BAF-B5DC-EF33995D5C8B">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0993C783-497B-4DFE-A1B6-3C24B7B5480C">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F58EF497-5BD1-49BC-823E-0AFC7B61D398">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="256935BC-C964-4569-8C7B-2C39EC09CB63">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="E0F48360-BEBF-45DB-8237-38792F7FD334">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7C0B8A8E-A3A7-47CC-B586-6CAB483683B8">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="34D66C63-1826-4082-838C-F7334CF23E2D">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E7E94F93-BE33-4D34-B65C-5DA3AB4857A3">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7144F4F3-1626-48FB-9267-E6612C33CFA6">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8C78A0B4-D95D-4CE9-B32B-3FF44F26DBD4">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="24F9D1F4-DD01-4942-8308-AC4FD30857CA">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C6F43A02-FD71-463C-B6A1-7AAEC64078D2">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D2143C05-623F-416F-B64C-1D596EF71800">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AB6E7C7C-CE8A-41E9-9111-E863B9670696">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="909A4B56-E46E-43F0-B9C7-1199C001704C">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="036E9A9D-D4E0-4FBA-8455-78E0A997B06A">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FB34C91E-BFE4-4F42-B427-7061A7B095BD">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8B5D8F1F-270F-416A-BF18-E33090CF323C">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="50641FC3-38A3-4EDA-9F6D-9EDBB09207F6">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D980368A-57B7-4503-9C44-E899098AA546">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C57E2BB6-4F4A-486F-ACF8-5B24F726DE51">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BF3F2B3C-9742-4FB7-9BFA-11DFB873EEED">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C93256D0-43EE-4A55-A6A2-FEC842BEF419">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="714AA8B7-FCD3-488F-8423-AB8FCDFCF000">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="69B3C654-DC35-433B-A767-62D15CA40A3E">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E0B09F89-FB86-4722-A2E9-E913EE27CBA9">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="57897E72-EB19-4DE8-AA97-C2F68DF21006">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="97042C48-F9DC-4B23-AE7E-4F16A860A0FF">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A731E056-19C6-47B9-9681-616889FC5489">
      <SHORT-NAME>SecureCommunicationPropsSet</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C4581EF5-8A7F-40D1-8E81-B126D2058CDD">
      <SHORT-NAME>SWC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="33599F33-2E8D-4A27-9964-019BD966D670">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7F6168FF-3305-4D05-82F7-37FE508C42BC">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FEC66564-7CBA-4603-8088-BECCF687C312">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="500A57C8-1077-48F8-B02A-3CB5588D4C51">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1FD27829-B827-4D11-8824-868B23CECB57">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>